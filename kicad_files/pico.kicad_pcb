# Repository kumaokobo/pico-keyboard

File README.md:

# Pico Keyboard Rev.1

Pico Keyboard is designed for small hands.  
It adopted the footprint for [Kailh Mid-Height](http://www.kailh.com/en/Products/Ks/KHS/) smaller than Cherry MX compatible switches.  

**Japanese Manual is [here](README.ja.md).**

<div style="display:block;margin:50px auto;">

</div>

## Summary

  - [Bill of materials](#bill-of-materials)
  - [Assembly guide](#assembly-guide)
  - [Firmware](#firmware)
    - [Basic compiling and burning command](#basic-compiling-and-burning-command)
    - [First time burning](#first-time-burning)
    - [Burning keymap for 70 keys](#burning-keymap-for-70-keys)

## Bill of materials

| Qty | Item                                          | Notes                                               |
|----:|-----------------------------------------------|-----------------------------------------------------|
|   2 | Pico PCBs                                     |                                                     |
|  65 | 1N4148 diodes                                 | SMD diodes can also be used                         |
|   2 | PJ-320A 4 poles 3.5 mm TRRS connectors        |                                                     |
|   2 | 4.7 kΩ resistors                              | Need to be soldered on one half only                |
|   2 | Through hole momentary switch                 | Dimensions 6mm x 6mm x 4.3mm                        |
|   2 | Arduino Pro Micro                             | ATMega32U4                                          |
|   1 | TRRS cable                                    |                                                     |
|   1 | USB micro cable                               |                                                     |
|   2 | Cases                                         |                                                     |
|  10 | Screws                                        | M3                                                  |
|  10 | Spacers                                       | M3                                                  |
|   8 | Washers                                       | M3 thickness 0.8mm                                  |
|   2 | Nuts                                          | M3 thickness 2.4mm                                  |
|  65 | [Kailh Mid-Height](http://www.kailh.com/en/Products/Ks/KHS/) | Brown, Red or Blue.                  |
|  65 | [Kailh Mid-Height](http://www.kailh.com/en/Products/Ks/KHS/) compatible keycaps | 65x 1u keycaps    |

> It is possible to assembly Pico Keyboard as 70 keys keyboard.
> In this case, you need 70 each 1N4148 diodes, switches, keycaps.

[Pico rev1 Basic](https://kumaokobo.booth.pm/items/1707764) is on sale at [BOOTH](https://kumaokobo.booth.pm/) (**NOT** including switches and keycaps).  

mulgrey created [Kailh Mid-Height](http://www.kailh.com/en/Products/Ks/KHS/) compatible keycaps! Thanks 🎉  
Thease are in DMM.make Creator's market.
- [DMM.make > mini keycap 72 pieces](https://make.dmm.com/item/1125390/)<div></div>

## Assembly guide

### Installation steps:

- Solder components on `Mounting Surface` side:
  1. Solder 1N4148 diodes. Keep the diode legs for the right hand controller installation.<br/><div></div>
  2. Solder PJ-320A connectors.
  3. Solder momentary switches.
  4. Solder 4.7 kΩ resistors **on one half only**.
  5. Solder the Pro Micro header pins (**do not solder the Pro Micro controllers yet**).
- Install upper cases to PCBs.
  * M3x10 screws → upper case → washers → PCB → spacers.<br/><div>
  <span>&nbsp;</span>
  </div>
- Fit switches to the upper cases and solder to the PCB.
- Solder Pro Micros to the header pins.
  * Solder Pro Micro face down.<br/><div>
  </div>

## Firmware

Pico keyboard uses [QMK Firmware](https://github.com/qmk/qmk_firmware) for its firmware.  
Follow the QMK installation instructions [here](https://docs.qmk.fm/#/newbs_getting_started), then compile and burn the firmware as follows:  

### Basic compiling and burning command

```sh
$ cd path/to/qmk_firmware
$ make pico/65keys:default:flash
```

※ If you burn a keymap for 70 keys, please see [Burning keymap for 70 keys](#burning-keymap-for-70-keys).  

### First time burning

You need to burn the firmware both left hand and right hand.

#### 1. Left hand side

Edit [pico/config.h](https://github.com/qmk/qmk_firmware/blob/master/keyboards/pico/config.h) and activate `MASTER_LEFT` .

```cpp
/* Select hand configuration */
#define MASTER_LEFT
// #define MASTER_RIGHT
// #define EE_HANDS
```

Save the file, then connect Pro Micro(**left hand**) and your PC by USB cable.  
Compile and burn the firmware by running [Basic compiling and burning command](#basic-compiling-and-burning-command) as follows:  

```sh
$ cd path/to/qmk_firmware
$ make pico/65keys:default:flash
```

#### 2. Right hand side

Edit [pico/config.h](https://github.com/qmk/qmk_firmware/blob/master/keyboards/pico/config.h) and activate `MASTER_RIGHT` .  

```cpp
/* Select hand configuration */
// #define MASTER_LEFT
#define MASTER_RIGHT
// #define EE_HANDS
```

Save the file, then connect Pro Micro(**right hand**) and your PC by USB cable.  
Compile and burn the firmware by running [Basic compiling and burning command](#basic-compiling-and-burning-command).  

#### 3. Confirmation

Pull out the USB cable, then connect left hand and right hand by TRRS cable.  
Plug in the Pro Micro (Master) the USB cable.  

### Burning keymap for 70 keys

Replace from `65keys` to `70keys` , and do the above 1 to 3.  

```sh
$ cd path/to/qmk_firmware
$ make pico/70keys:default:flash
```

## Layout

<em><a href="http://www.keyboard-layout-editor.com/">http://www.keyboard-layout-editor.com/</a></em>

### 65 keys default

[KLE Layout permalink](http://www.keyboard-layout-editor.com/##@_name=pico-keyboard%2065%20keys&author=kumaokobo%3Ckumaokobo%2F@gmail.com%3E%3B&@=~%0A%0A%60&_f2:2%3B&=1%0AF1%0A!&=2%0AF2%0A%2F@&=3%0AF3%0A%23&=4%0AF4%0A$&=5%0AF5%0A%25&_x:3%3B&=6%0AF6%0A%5E&=7%0AF7%0A%2F&&=8%0AF8%0A*&=9%0AF9%0A(&=0%0AF10%0A)&=-%0AF11%0A%2F_&=%E2%86%90%0AF12%0Aback%3B&@_x:0.25%3B&=Tab&=Q&=W&=E&=R&=T&_x:3&f:3%3B&=Y%0A(&_f:3%3B&=U%0A)&_f:3%3B&=I%0A%7C&_f:3%3B&=O%0A*&_f:3%3B&=P%0A~&_f:3%3B&=%5B%0A%C2%A5%0A%7B&_f:3%3B&=%5D%0A%5C%0A%7D%3B&@_x:0.5%3B&=Ctrl&=A&=S&=D&=F&=G&_x:3&f:3%3B&=H%0A%5B&_f:3%3B&=J%0A%5D&_f:3%3B&=K%0A.&_f:3%3B&=L%0A%2F%2F&_f:3%3B&=%2F%3B%0A%60%0A%2F:&_f:3%3B&='%0A-%0A%22&=Enter%3B&@_x:0.75%3B&=Shift&=Z&=X&=C&=V&=B&_x:3&f:3%3B&=N%0A%7B&_f:3%3B&=M%0A%7D&_f:3%3B&=,%0A%0A%3C&_f:3%3B&=.%0A%0A%3E&_f:3%3B&=%2F%2F%0A%0A%3F&_f:3%3B&=%E2%86%91%0A%5E&=Shift%3B&@_x:1&f:3%3B&=Alt%0A%0A%0AEsc&=Enter&=Del&=GUI&_fa@:2&:2%3B%3B&=LANG2%0Alayer&_f:3%3B&=Space&_x:3&f:3%3B&=Space&_f:3%3B&=LANG1%0Alayer&_f:3%3B&=GUI&_f:3%3B&=Del&_f:3%3B&=%E2%86%90%0A%3C&_f:3%3B&=%E2%86%93%0A%2F_&_f:3%3B&=%E2%86%92%0A%3E)

### 70 keys default

[KLE Layout permalink](http://www.keyboard-layout-editor.com/##@_name=pico-keyboard%2070%20keys&author=kumaokobo%3Ckumaokobo%2F@gmail.com%3E%3B&@=Esc&=~%0A%0A%60&_f2:2%3B&=1%0AF1%0A!&=2%0AF2%0A%2F@&=3%0AF3%0A%23&=4%0AF4%0A$&=5%0AF5%0A%25&_x:2%3B&=6%0AF6%0A%5E&=7%0AF7%0A%2F&&=8%0AF8%0A*&=9%0AF9%0A(&=0%0AF10%0A)&=-%0AF11%0A%2F_&=%E2%86%90%0AF12%0Aback%3B&@_x:0.25%3B&=Tab&=Tab&=Q&=W&=E&=R&=T&_x:2&f:3%3B&=Y%0A(&_f:3%3B&=U%0A)&_f:3%3B&=I%0A%7C&_f:3%3B&=O%0A*&_f:3%3B&=P%0A~&_f:3%3B&=%5B%0A%C2%A5%0A%7B&_f:3%3B&=%5D%0A%5C%0A%7D%3B&@_x:0.5%3B&=Ctrl&=Ctrl&=A&=S&=D&=F&=G&_x:2&f:3%3B&=H%0A%5B&_f:3%3B&=J%0A%5D&_f:3%3B&=K%0A.&_f:3%3B&=L%0A%2F%2F&_f:3%3B&=%2F%3B%0A%60%0A%2F:&_f:3%3B&='%0A-%0A%22&=Enter%3B&@_x:0.75%3B&=Shift&=Shift&=Z&=X&=C&=V&=B&_x:2&f:3%3B&=N%0A%7B&_f:3%3B&=M%0A%7D&_f:3%3B&=,%0A%0A%3C&_f:3%3B&=.%0A%0A%3E&_f:3%3B&=%2F%2F%0A%0A%3F&_f:3%3B&=%E2%86%91%0A%5E&=Shift%3B&@_x:1%3B&=Alt%0A%0A%0AEsc&=Alt%0A%0A%0AEsc&=Enter&=Del&=GUI&_fa@:2&:2%3B%3B&=LANG2%0Alayer&_f:3%3B&=Space&_x:2&f:3%3B&=Space&_f:3%3B&=LANG1%0Alayer&_f:3%3B&=GUI&_f:3%3B&=Del&_f:3%3B&=%E2%86%90%0A%3C&_f:3%3B&=%E2%86%93%0A%2F_&_f:3%3B&=%E2%86%92%0A%3E)

## KiCad design kicad_files/pico.kicad_pcb

Parts:
D0, D1, D2, D3, D4, D5, D6, D10, D11, D12, D13, D14, D15, D16, D20, D21, D22, D23, D24, D25, D26, D30, D31, D32, D33, D34, D35, D36, D40, D41, D42, D43, D44, D45, D46: D; Diode-dual
K0, K1, K2, K3, K4, K5, K6, K10, K11, K12, K13, K14, K15, K16, K20, K21, K22, K23, K24, K25, K26, K30, K31, K32, K33, K34, K35, K36, K40, K41, K42, K43, K44, K45, K46: KEYSW; Kailh_mid_height
R1, R2: 4.7k; Resistor-Compact
RGB_STRIP1: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
RST_SW1: SW_PUSH; SW_PUSH_6mm_h4.3mm
TRRS1: Audio-Jack-4; TRRS-PJ-320A
U1: ProMicro; ArduinoProMicro

Connections:
GND: RGB_STRIP1.3, RST_SW1.2, TRRS1.4, U1.3 (GND), U1.4 (GND), U1.23 (GND)
unnamed: D0.2 (A), K0.2
unnamed: D1.2 (A), K1.2
unnamed: D2.2 (A), K2.2
unnamed: D3.2 (A), K3.2
unnamed: D4.2 (A), K4.2
unnamed: D5.2 (A), K5.2
unnamed: D6.2 (A), K6.2
unnamed: D10.2 (A), K10.2
unnamed: D11.2 (A), K11.2
unnamed: D12.2 (A), K12.2
unnamed: D13.2 (A), K13.2
unnamed: D14.2 (A), K14.2
unnamed: D15.2 (A), K15.2
unnamed: D16.2 (A), K16.2
unnamed: D20.2 (A), K20.2
unnamed: D21.2 (A), K21.2
unnamed: D22.2 (A), K22.2
unnamed: D23.2 (A), K23.2
unnamed: D24.2 (A), K24.2
unnamed: D25.2 (A), K25.2
unnamed: D26.2 (A), K26.2
unnamed: D30.2 (A), K30.2
unnamed: D31.2 (A), K31.2
unnamed: D32.2 (A), K32.2
unnamed: D33.2 (A), K33.2
unnamed: D34.2 (A), K34.2
unnamed: D35.2 (A), K35.2
unnamed: D36.2 (A), K36.2
unnamed: D40.2 (A), K40.2
unnamed: D41.2 (A), K41.2
unnamed: D42.2 (A), K42.2
unnamed: D43.2 (A), K43.2
unnamed: D44.2 (A), K44.2
unnamed: D45.2 (A), K45.2
unnamed: D46.2 (A), K46.2
RST: RST_SW1.1, U1.22 (RST)
SCL: R2.1, TRRS1.2, U1.6 (3/PD0)
SDA: R1.1, TRRS1.3, U1.5 (2/PD1)
VCC: R1.2, R2.2, RGB_STRIP1.1, TRRS1.1, U1.21 (VCC)
col0: K0.1, K10.1, K20.1, K30.1, K40.1, U1.19 (A2/PF5)
col1: K1.1, K11.1, K21.1, K31.1, K41.1, U1.18 (A1/PF6)
col2: K2.1, K12.1, K22.1, K32.1, K42.1, U1.17 (A0/PF7)
col3: K3.1, K13.1, K23.1, K33.1, K43.1, U1.16 (15/PB1)
col4: K4.1, K14.1, K24.1, K34.1, K44.1, U1.15 (14/PB3)
col5: K5.1, K15.1, K25.1, K35.1, K45.1, U1.14 (16/PB2)
col6: K6.1, K16.1, K26.1, K36.1, K46.1, U1.13 (10/PB6)
rgb_data: RGB_STRIP1.2, U1.1 (TX0/PD3)
row0: D0.1 (K), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), U1.7 (4/PD4)
row1: D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U1.9 (6/PD7)
row2: D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), U1.10 (7/PE6)
row3: D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.11 (8/PB4)
row4: D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), U1.12 (9/PB5)

Board: 2 copper layers, 131.4 x 96.5 mm, 80 parts (1 on the bottom side), 53 nets.

Other parts of the board:
HOLE_M3, HOLE_M3#2, HOLE_M3#3, HOLE_M3#4: VAL**; HOLE_M3

## Commit log

2019-11-08 Modified outline of pico keyboard.
2019-11-08 Modified sign of schematic.
2019-11-08 Feature rev1 (#1)
    * First commit
    * Modified outline of pico keyboard.
    * Modified sign of schematic.
2019-11-08 Modified vertical guide line.
2019-11-08 Modified vertical guide line. (#2)
2019-11-19 Move .gitignore to root.
2019-11-19 Add images of pico-keyboard.
2019-11-19 Add descriptions on README.
2019-11-19 Modified the explain of soldering ProMicro.
2019-11-19 Modified slightly mistakes.
2019-11-19 Modified readme(en) and add readme(jp) (#3)
    * Move .gitignore to root.
    * Add images of pico-keyboard.
    * Add descriptions on README.
    * Modified the explain of soldering ProMicro.
    * Modified slightly mistakes.
2019-12-02 Modified README.
2019-12-02 Modified README. (#4)
2019-12-03 Modified links of booth.
2019-12-03 Modified links of booth. (#5)
2019-12-16 Add 70 keys layouts.
2019-12-16 Add how to burn 70 keys keymap.
2019-12-16 Add a notification when burning keymap for 70 keys.
2019-12-16 [layout] Add 70 keys layouts. (#6)
    * Add 70 keys layouts.
    * Add how to burn 70 keys keymap.
    * Add a notification when burning keymap for 70 keys.
